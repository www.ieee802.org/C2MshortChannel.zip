# GHz S RI R 50
! S-Parameters data
! Freq  reS11  imS11  reS12  imS12  reS13  imS13  reS14  imS14
!  reS21  imS21  reS22  imS22  reS23  imS23  reS24  imS24
!  reS31  imS31  reS32  imS32  reS33  imS33  reS34  imS34
!  reS41  imS41  reS42  imS42  reS43  imS43  reS44  imS44
! Worked out from all points (4-port):
!   2001 points, 1 Hz to 40 GHz, reference 50 ohm
!   strongest paths, dB at 1 Hz, 10 GHz, 20 GHz, 30 GHz, 40 GHz:
!     S42: -78.3, -12.3, -14.1, -17.7, -12.4
!     S31: -77.3, -15.7, -23.1, -20.0, -11.7
!     S21: -93.4, -44.6, -30.6, -34.5, -44.0
!     S32: -92.2, -41.6, -36.6, -30.0, -33.2
!     S41: -93.8, -56.0, -36.3, -30.9, -33.3
!     S43: -91.2, -37.8, -47.3, -32.3, -28.5
!   lowest |S11| = -46.9 dB at 1 Hz (marker M1), VSWR 1.01, Z = 50.5 - j1.01e-08 ohm
!   |S11| at or under -10 dB: 3.773 GHz to 6.72 GHz (2.947 GHz wide, 56.2 % of centre); 7.127 GHz to 11.31 GHz (4.183 GHz wide, 45.4 % of centre); 14.25 GHz to 19.63 GHz (5.38 GHz wide, 31.8 % of centre) (the widest 3 of 11)
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! magnitudes (dB):
! f  S11  S42  S31  S21  S32  S41  S43
! 1 Hz  -46.9  -78.3  -77.3  -93.4  -92.2  -93.8  -91.2
! 460 MHz  -21.2  -20.2  -17.9  -48.0  -45.5  -49.5  -45.9
! 2.46 GHz  -11.8  -11.2  -16.0  -34.2  -33.0  -32.5  -33.3
! 12.8 GHz  -16.0  -12.6  -10.3  -26.8  -28.3  -26.9  -25.5
! 16.2 GHz  -11.6  -18.4  -17.3  -37.3  -66.9  -42.4  -40.7
! 17.1 GHz  -21.3  -13.1  -16.5  -31.8  -28.8  -32.6  -31.0
! 40 GHz  -7.6  -12.4  -11.7  -44.0  -33.2  -33.3  -28.5
