# GHz S RI R 50
! S-Parameters data
! Freq  reS11  imS11  reS12  imS12  reS13  imS13  reS14  imS14
!  reS21  imS21  reS22  imS22  reS23  imS23  reS24  imS24
!  reS31  imS31  reS32  imS32  reS33  imS33  reS34  imS34
!  reS41  imS41  reS42  imS42  reS43  imS43  reS44  imS44
! Worked out from all points (4-port):
!   2001 points, 1 Hz to 40 GHz, reference 50 ohm
!   strongest paths, dB at 1 Hz, 10 GHz, 20 GHz, 30 GHz, 40 GHz:
!     S31: -78.1, -13.1, -17.8, -9.5, -10.0
!     S42: -78.3, -12.3, -14.1, -17.7, -12.4
!     S43: -87.4, -25.7, -21.3, -29.0, -44.9
!     S21: -88.5, -27.8, -21.0, -22.6, -55.5
!     S32: -86.4, -26.5, -23.8, -27.0, -44.2
!     S41: -90.8, -31.2, -34.4, -26.0, -37.9
!   lowest |S11| = -47.0 dB at 1 Hz (marker M1), VSWR 1.01, Z = 50.4 - j1.01e-08 ohm
!   |S11| at or under -10 dB: 6.115 GHz to 9.596 GHz (3.481 GHz wide, 44.3 % of centre); 14.79 GHz to 17.04 GHz (2.249 GHz wide, 14.1 % of centre); 25.45 GHz to 32.64 GHz (7.187 GHz wide, 24.7 % of centre) (the widest 3 of 11)
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! magnitudes (dB):
! f  S11  S31  S42  S43  S21  S32  S41
! 1 Hz  -47.0  -78.1  -78.3  -87.4  -88.5  -86.4  -90.8
! 460 MHz  -28.7  -19.9  -20.2  -39.7  -40.4  -39.0  -43.0
! 2.46 GHz  -8.5  -11.4  -11.2  -29.7  -31.5  -29.4  -33.2
! 21.28 GHz  -6.4  -12.1  -20.1  -22.5  -16.8  -27.5  -22.8
! 24.86 GHz  -10.2  -11.6  -12.3  -22.7  -27.5  -34.4  -49.6
! 30.22 GHz  -30.6  -7.4  -19.4  -27.8  -22.3  -25.4  -26.8
! 40 GHz  -6.8  -10.0  -12.4  -44.9  -55.5  -44.2  -37.9
