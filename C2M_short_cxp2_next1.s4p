# GHz S RI R 50
! S-Parameters data
! Freq  reS11  imS11  reS12  imS12  reS13  imS13  reS14  imS14
!  reS21  imS21  reS22  imS22  reS23  imS23  reS24  imS24
!  reS31  imS31  reS32  imS32  reS33  imS33  reS34  imS34
!  reS41  imS41  reS42  imS42  reS43  imS43  reS44  imS44
! Worked out from all points (4-port):
!   2001 points, 1 Hz to 40 GHz, reference 50 ohm
!   strongest paths, dB at 1 Hz, 10 GHz, 20 GHz, 30 GHz, 40 GHz:
!     S42: -78.3, -12.3, -14.1, -17.7, -12.4
!     S31: -78.1, -12.3, -16.5, -17.4, -11.9
!     S21: -88.4, -28.4, -22.6, -24.6, -32.3
!     S32: -86.3, -25.6, -29.7, -14.9, -24.6
!     S43: -87.3, -28.1, -27.5, -23.1, -35.3
!     S41: -90.7, -28.8, -25.0, -33.8, -27.1
!   lowest |S11| = -47.0 dB at 1 Hz (marker M1), VSWR 1.01, Z = 50.4 - j1.01e-08 ohm
!   |S11| at or under -10 dB: 6.217 GHz to 13.44 GHz (7.218 GHz wide, 73.5 % of centre); 14.11 GHz to 18.55 GHz (4.441 GHz wide, 27.2 % of centre); 18.71 GHz to 21.65 GHz (2.933 GHz wide, 14.5 % of centre) (the widest 3 of 9)
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! magnitudes (dB):
! f  S11  S42  S31  S21  S32  S43  S41
! 1 Hz  -47.0  -78.3  -78.1  -88.4  -86.3  -87.3  -90.7
! 440 MHz  -24.7  -20.5  -20.5  -40.1  -37.0  -39.7  -43.2
! 2.46 GHz  -9.5  -11.2  -11.1  -33.3  -28.3  -32.9  -35.0
! 24.08 GHz  -6.1  -19.1  -23.9  -24.9  -50.7  -39.3  -25.5
! 30.42 GHz  -6.3  -20.3  -21.4  -22.0  -12.9  -20.4  -29.0
! 35.64 GHz  -4.5  -21.0  -22.9  -39.6  -51.1  -38.3  -38.1
! 40 GHz  -7.9  -12.4  -11.9  -32.3  -24.6  -35.3  -27.1
