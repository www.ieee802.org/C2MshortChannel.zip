# GHz S RI R 50
! S-Parameters data
! Freq  reS11  imS11  reS12  imS12  reS13  imS13  reS14  imS14
!  reS21  imS21  reS22  imS22  reS23  imS23  reS24  imS24
!  reS31  imS31  reS32  imS32  reS33  imS33  reS34  imS34
!  reS41  imS41  reS42  imS42  reS43  imS43  reS44  imS44
! Worked out from all points (4-port):
!   2001 points, 1 Hz to 40 GHz, reference 50 ohm
!   strongest paths, dB at 1 Hz, 10 GHz, 20 GHz, 30 GHz, 40 GHz:
!     S31: -77.2, -13.2, -13.0, -10.4, -10.3
!     S42: -78.3, -12.3, -14.1, -17.7, -12.4
!     S43: -91.2, -31.4, -26.7, -31.5, -52.3
!     S41: -93.9, -37.3, -32.8, -25.4, -50.5
!     S21: -93.5, -37.3, -30.4, -27.2, -40.0
!     S32: -92.2, -37.5, -32.1, -34.3, -46.0
!   lowest |S11| = -46.9 dB at 1 Hz (marker M1), VSWR 1.01, Z = 50.5 - j1.01e-08 ohm
!   |S11| at or under -10 dB: 3.757 GHz to 6.677 GHz (2.92 GHz wide, 56 % of centre); 7.383 GHz to 10.71 GHz (3.328 GHz wide, 36.8 % of centre); 24.7 GHz to 32.7 GHz (8.006 GHz wide, 27.9 % of centre) (the widest 3 of 12)
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! magnitudes (dB):
! f  S11  S31  S42  S43  S41  S21  S32
! 1 Hz  -46.9  -77.2  -78.3  -91.2  -93.9  -93.5  -92.2
! 460 MHz  -23.4  -17.6  -20.2  -46.1  -49.8  -48.4  -47.2
! 2.46 GHz  -7.5  -10.5  -11.2  -32.1  -35.1  -36.3  -34.2
! 5.36 GHz  -16.8  -32.1  -13.2  -33.2  -41.5  -42.4  -39.7
! 24.24 GHz  -7.7  -9.4  -17.5  -26.7  -25.8  -24.2  -26.5
! 28.58 GHz  -13.4  -6.2  -15.3  -31.6  -34.6  -29.4  -36.8
! 40 GHz  -6.8  -10.3  -12.4  -52.3  -50.5  -40.0  -46.0
