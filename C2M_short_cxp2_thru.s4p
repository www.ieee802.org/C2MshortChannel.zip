# GHz S RI R 50
! S-Parameters data
! Freq  reS11  imS11  reS12  imS12  reS13  imS13  reS14  imS14
!  reS21  imS21  reS22  imS22  reS23  imS23  reS24  imS24
!  reS31  imS31  reS32  imS32  reS33  imS33  reS34  imS34
!  reS41  imS41  reS42  imS42  reS43  imS43  reS44  imS44
! Worked out from all points (differential pair):
!   2001 points, 1 Hz to 40 GHz, reference 50 ohm
!   strongest paths, dB at 1 Hz, 10 GHz, 20 GHz, 30 GHz, 40 GHz:
!     S21: 0.0, -3.4, -5.7, -15.1, -32.5
!     S43: 0.0, -3.6, -6.4, -19.2, -38.0
!     S31: -78.3, -12.9, -21.0, -9.2, -10.2
!     S42: -78.3, -12.3, -14.1, -17.7, -12.4
!     S41: -78.5, -13.8, -12.4, -13.2, -37.2
!     S32: -78.5, -13.7, -13.0, -14.9, -40.7
!   taken as a pair (ports 1,3 in; 2,4 out), SDD21 dB: 0.0, -1.8, -4.4, -11.3, -32.2
!   lowest |S11| = -56.4 dB at 30.34 GHz (marker M1), VSWR 1.00, Z = 50.1 - j0.0788 ohm
!   |S11| at or under -10 dB: 6.139 GHz to 9.581 GHz (3.442 GHz wide, 43.8 % of centre); 11.24 GHz to 13.23 GHz (1.987 GHz wide, 16.2 % of centre); 27.03 GHz to 32.58 GHz (5.546 GHz wide, 18.6 % of centre) (the widest 3 of 12)
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! magnitudes (dB):
! f  S11  S21  S43  S31  S42  S41  S32
! 1 Hz  -47.0  0.0  0.0  -78.3  -78.3  -78.5  -78.5
! 460 MHz  -29.3  -0.2  -0.2  -19.9  -20.2  -28.6  -28.5
! 2.44 GHz  -8.7  -1.9  -2.0  -11.4  -11.1  -15.8  -16.0
! 7.06 GHz  -28.2  -1.5  -1.5  -16.9  -19.1  -27.4  -25.4
! 25.44 GHz  -7.3  -8.4  -11.5  -18.7  -13.4  -14.3  -14.3
! 30.34 GHz  -56.4  -18.1  -17.9  -6.7  -20.1  -13.5  -17.2
! 40 GHz  -7.4  -32.5  -38.0  -10.2  -12.4  -37.2  -40.7
